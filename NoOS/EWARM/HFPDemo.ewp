# IAR project HFPDemo.ewp, settings and files
configuration Debug - DK-TM4C123G (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RB1; DEBUG_ZONES=DBG_ZONE_ANY; __SUPPORT_CC256XB_PATCH__
  ICCARM.IExtraOptions: -f ..\..\..\..\BuildScripts\TivaWarePath_DK_TM4C123G_EWARM.txt
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\Hardware; ..\..\..\..\Hardware\dk-tm4c123g; ..\..\..\..\Bluetopia\include; ..\..\..\..\Bluetopia\btpskrnl\noos; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\btvs\include; ..\..\..\..\Bluetopia\hcitrans\noos; ..\..\..\..\Bluetopia\profiles\hfp\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HFPDemo.bin
  prebuild: ..\..\..\..\BuildScripts\SetTivaWarePath.bat "$PROJ_DIR$"
  ILINK.IlinkOutputFile: HFPDemo.out
  ILINK.IlinkIcfFile: ..\startup\dk_tm4c123g\linker_ewarm.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\BuildScripts\TivaWarePath_DK_TM4C123G_LD_EWARM.txt
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Bluetopia\lib\ewarm\NoOS\Bluetopia.a; ..\..\..\..\Bluetopia\profiles\hfp\lib\ewarm\SS1BTHFP.a; driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release - DK-TM4C123G (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RB1; DEBUG_ZONES=0; __SUPPORT_CC256XB_PATCH__
  ICCARM.CCOptLevel: 3
configuration Debug - DK-TM4C129X (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_SNOWFLAKE_RA0; DEBUG_ZONES=DBG_ZONE_ANY; __SUPPORT_CC256XB_PATCH__
  ICCARM.IExtraOptions: -f ..\..\..\..\BuildScripts\TivaWarePath_DK_TM4C129X_EWARM.txt
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\Hardware; ..\..\..\..\Hardware\dk-tm4c129x; ..\..\..\..\Bluetopia\include; ..\..\..\..\Bluetopia\btpskrnl\noos; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\btvs\include; ..\..\..\..\Bluetopia\hcitrans\noos; ..\..\..\..\Bluetopia\profiles\hfp\include
  ILINK.IlinkIcfFile: ..\startup\dk_tm4c129x\linker_ewarm.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\BuildScripts\TivaWarePath_DK_TM4C129X_LD_EWARM.txt
configuration Release - DK-TM4C129X (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG; PART_TM4C129XNCZAD; TARGET_IS_SNOWFLAKE_RA0; DEBUG_ZONES=0; __SUPPORT_CC256XB_PATCH__
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\startup\dk_tm4c129x\linker_ewarm.icf
  ILINK.IlinkExtraOptions: as above
  group Application
    ../../../../Hardware/: HAL.c
    ../../: HFPDemo.c TivaWareLib.c
    ../: Main.c
  group Bluetopia
    ../../../../Bluetopia/btpskrnl/NoOS/: BTPSKRNL.c
    ../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../Bluetopia/btvs/source/: BTVS.c
    ../../../../Bluetopia/hcitrans/NoOS/: HCITRANS.c
  group dk-tm4c123g
    ../startup/dk_tm4c123g/: startup_ewarm.c
  group dk-tm4c129x
    ../startup/dk_tm4c129x/: startup_ewarm.c
