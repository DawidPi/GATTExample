# Keil uVision project HFPDemo.uvproj, settings and files
target HFP (DK-TM4C123G) Debug Target (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: HFPDemo
  BeforeMake: ..\..\..\..\BuildScripts\SetTivaWarePath.bat
  AfterMake: fromelf.exe --output "Debug - DK-TM4C123G/HFPDemo.bin" --bin "Debug - DK-TM4C123G/HFPDemo.axf"
  c flags: Optim=1 OneElfS=1
  c define: PART_TM4C123GH6PGE, TARGET_IS_BLIZZARD_RB1, DEBUG, DEBUG_ENABLED, DEBUG_ZONES=DBG_ZONE_ANY, __SUPPORT_CC256XB_PATCH__
  c misc: --via ..\..\..\..\BuildScripts\TivaWarePath_DK_TM4C123G_RVMDK.txt --c99
  c include: ..\..\..\..\Hardware;..\..\..\..\Hardware\dk-tm4c123g;..;..\..;..\..\..\..\Bluetopia\include;..\..\..\..\Bluetopia\btpskrnl\NoOS;..\..\..\..\Bluetopia\btpsvend;..\..\..\..\Bluetopia\hcitrans\NoOS;..\..\..\..\Bluetopia\btvs\include;..\..\..\..\Bluetopia\profiles\hfp\include
  scatter file: ..\startup\dk_tm4c123g\linker_rvmdk.sct
  link misc: --entry Reset_Handler driverlib.lib --via ..\..\..\..\BuildScripts\TivaWarePath_DK_TM4C123G_LD_RVMDK.txt
  group Sample Source
    ../: Main.c
    ../../: HFPDemo.c TivaWareLib.c
  group Libraries
    ../../../../Bluetopia/lib/rvmdk/NoOS/: Bluetopia.lib
    ../../../../Bluetopia/btvs/lib/rvmdk/: SS1BTVS.lib
    ../../../../Bluetopia/profiles/hfp/lib/rvmdk/: SS1BTHFP.lib
  group Bluetopia Source
    ../../../../Bluetopia/btpskrnl/NoOS/: BTPSKRNL.c
    ../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../Bluetopia/hcitrans/NoOS/: HCITRANS.c
    ../../../../Bluetopia/btvs/source/: BTVS.c
  group Hardware Source
    ../../../../Hardware/: HAL.c
  group dk-tm4c123g
    ../startup/dk_tm4c123g/: startup_rvmdk.S
  group dk-tm4c129x
    ../startup/dk_tm4c129x/: startup_rvmdk.S
target HFP (DK-TM4C123G) Release Target (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: HFPDemo
  BeforeMake: ..\..\..\..\BuildScripts\SetTivaWarePath.bat
  AfterMake: fromelf.exe --output "Release - DK-TM4C123G/HFPDemo.bin" --bin "Release - DK-TM4C123G/HFPDemo.axf"
  c flags: Optim=4 OneElfS=1
  c define: PART_TM4C123GH6PGE, TARGET_IS_BLIZZARD_RB1, DEBUG_ZONES=0, __SUPPORT_CC256XB_PATCH__
  c misc: as above
  c include: as above
  scatter file: ..\startup\dk_tm4c123g\linker_rvmdk.sct
  link misc: as above
target HFP (DK-TM4C129X) Debug Target (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: HFPDemo
  BeforeMake: ..\..\..\..\BuildScripts\SetTivaWarePath.bat
  AfterMake: fromelf.exe --output "Debug - DK-TM4C129X/HFPDemo.bin" --bin "Debug - DK-TM4C129X/HFPDemo.axf"
  c flags: Optim=1 OneElfS=1
  c define: PART_TM4C129XNCZAD, TARGET_IS_SNOWFLAKE_RA0, DEBUG, DEBUG_ENABLED, DEBUG_ZONES=DBG_ZONE_ANY, __SUPPORT_CC256XB_PATCH__
  c misc: --via ..\..\..\..\BuildScripts\TivaWarePath_DK_TM4C129X_RVMDK.txt --c99
  c include: ..\..\..\..\Hardware;..\..\..\..\Hardware\dk-tm4c129x;..;..\..;..\..\..\..\Bluetopia\include;..\..\..\..\Bluetopia\btpskrnl\NoOS;..\..\..\..\Bluetopia\btpsvend;..\..\..\..\Bluetopia\hcitrans\NoOS;..\..\..\..\Bluetopia\btvs\include;..\..\..\..\Bluetopia\profiles\hfp\include
  scatter file: ..\startup\dk_tm4c129x\linker_rvmdk.sct
  link misc: --entry Reset_Handler driverlib.lib --via ..\..\..\..\BuildScripts\TivaWarePath_DK_TM4C129X_LD_RVMDK.txt
target HFP (DK-TM4C129X) Release Target (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: HFPDemo
  BeforeMake: ..\..\..\..\BuildScripts\SetTivaWarePath.bat
  AfterMake: fromelf.exe --output "Release - DK-TM4C129X/HFPDemo.bin" --bin "Release - DK-TM4C129X/HFPDemo.axf"
  c flags: Optim=4 OneElfS=1
  c define: PART_TM4C129XNCZAD, TARGET_IS_SNOWFLAKE_RA0, DEBUG_ZONES=0, __SUPPORT_CC256XB_PATCH__
  c misc: as above
  c include: as above
  scatter file: ..\startup\dk_tm4c129x\linker_rvmdk.sct
  link misc: as above
